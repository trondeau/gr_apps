<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp2_tx_qt</value></param>
<param><key>title</key><value>Transmit FM Signal - USRP2 based wiht QtGUI</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>sig_freq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sig_freq</value></param>
<param><key>label</key><value>Input Frequency</value></param>
<param><key>value</key><value>1e3</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>4e3</value></param>
<param><key>step</key><value>100</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>label</key><value>Output Amplitude</value></param>
<param><key>value</key><value>0.010</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.010</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>gr_sig_source_x</key>
<param><key>id</key><value>gr_sig_source_x_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samp_rate</key><value>bandwidth</value></param>
<param><key>waveform</key><value>gr.GR_COS_WAVE</value></param>
<param><key>freq</key><value>sig_freq</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>offset</key><value>0</value></param>
</block>
<block>
<key>blks2_wfm_tx</key>
<param><key>id</key><value>blks2_wfm_tx_0</value></param>
<param><key>audio_rate</key><value>int(samp_rate)</value></param>
<param><key>quad_rate</key><value>int(bandwidth)</value></param>
<param><key>tau</key><value>75e-6</value></param>
<param><key>max_dev</key><value>5e3</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>value</key><value>400e3</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>W</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain - WBX</value></param>
<param><key>value</key><value>10</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Freq - WBX</value></param>
<param><key>value</key><value>440e6</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>stop</key><value>2200e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>amplitude</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
</block>
<block>
<key>usrp2_sink_xxxx</key>
<param><key>id</key><value>usrp2_sink_xxxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interface</key><value>interface</value></param>
<param><key>mac_addr</key><value></value></param>
<param><key>interpolation</key><value>interp</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>usrp2_clock_src</key><value>usrp2.MC_WE_DONT_LOCK</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>interp</value></param>
<param><key>value</key><value>int(100e6/bandwidth)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interface</value></param>
<param><key>label</key><value>Ethernet Interface</value></param>
<param><key>value</key><value>eth1</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>e</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>bandwidth/8</value></param>
</block>
<connection><source_block_id>gr_sig_source_x_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_sig_source_x_0</source_block_id><sink_block_id>blks2_wfm_tx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_wfm_tx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>usrp2_sink_xxxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
