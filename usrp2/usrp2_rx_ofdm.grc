<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>usrp2_rx_ofdm</value></param>
<param><key>title</key><value>OFDM Receiver</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>decim</value></param>
<param><key>value</key><value>int(100e6/bandwidth)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>interface</value></param>
<param><key>label</key><value>Ethernet Interface</value></param>
<param><key>value</key><value>eth1</value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>e</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>FFT Output</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>plotfreq</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@4</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>Freq. Sync</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>plotfreq</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Freq. Corrected Signal</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>plotfreq</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@3</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_1</value></param>
<param><key>type</key><value>float</value></param>
<param><key>name</key><value>Time Sync</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>plotfreq</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@2</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Input</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0</value></param>
</block>
<block>
<key>ofdm_rx</key>
<param><key>id</key><value>ofdm_rx_0</value></param>
<param><key>fft_len</key><value>64</value></param>
<param><key>cp_len</key><value>16</value></param>
<param><key>occ_tones</key><value>40</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>amplitude</value></param>
<param><key>label</key><value>Rx Amplitude</value></param>
<param><key>value</key><value>40</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1000</value></param>
<param><key>step</key><value>10</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>amplitude</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_fft_filter_xxx</key>
<param><key>id</key><value>gr_fft_filter_xxx_0</value></param>
<param><key>type</key><value>ccc</value></param>
<param><key>decim</key><value>1</value></param>
<param><key>taps</key><value>ch_taps</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>WBX - Gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>31.5</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Freq - WBX</value></param>
<param><key>value</key><value>440e6</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>stop</key><value>2.2e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tb</value></param>
<param><key>value</key><value>0.25*bw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>bw</value></param>
<param><key>value</key><value>0.5 * float(occ_tones) / float(fft_len)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ch_taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(1.0, 1.0, bw+tb, tb, 80)</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>num_tabs</key><value>5</value></param>
<param><key>label0</key><value>Input</value></param>
<param><key>label1</key><value>Freq. Sync</value></param>
<param><key>label2</key><value>Time Sync</value></param>
<param><key>label3</key><value>FFT Output</value></param>
<param><key>label4</key><value>Frame Acq. Output</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>value</key><value>512</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>occ_tones</value></param>
<param><key>label</key><value>Number of Occupied Tones</value></param>
<param><key>value</key><value>200</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>Lenght of Cyclic Prefix</value></param>
<param><key>value</key><value>64</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>usrp2_source_xxxx</key>
<param><key>id</key><value>usrp2_source_xxxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>interface</key><value>interface</value></param>
<param><key>mac_addr</key><value></value></param>
<param><key>decimation</key><value>decim</value></param>
<param><key>frequency</key><value>freq</value></param>
<param><key>lo_offset</key><value>float('inf')</value></param>
<param><key>gain</key><value>gain</value></param>
<param><key>usrp2_clock_src</key><value>usrp2.MC_WE_DONT_LOCK</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>value</key><value>500e3</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>W</value></param>
</block>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_filter_xxx_0</source_block_id><sink_block_id>ofdm_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_rx_0</source_block_id><sink_block_id>qtgui_sink_x_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_rx_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_rx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ofdm_rx_0</source_block_id><sink_block_id>qtgui_sink_x_0_0_0_0_0</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>gr_fft_filter_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>usrp2_source_xxxx_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
