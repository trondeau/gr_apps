<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_tx_psk_channels</value></param>
<param><key>title</key><value>Channelized PSK Transmitter</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Tx Gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>25</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Carrier Frequency</value></param>
<param><key>value</key><value>440.023e6</value></param>
<param><key>start</key><value>400e6</value></param>
<param><key>stop</key><value>500e6</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>scipy.array(scipy.random.randint(0,256,10000), dtype=scipy.uint8).tolist()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>out_amp</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>blks2_dxpsk_mod</key>
<param><key>id</key><value>blks2_dxpsk_mod_0</value></param>
<param><key>type</key><value>dbpsk</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>gray_code</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>sig_amp0</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>sig_amp1</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>scipy.array(scipy.random.randint(0,256,10000), dtype=scipy.uint8).tolist()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>scipy.array(scipy.random.randint(0,256,10000), dtype=scipy.uint8).tolist()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0_0_1</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>scipy.array(scipy.random.randint(0,256,10000), dtype=scipy.uint8).tolist()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_pfb_synthesis_filterbank_ccf</key>
<param><key>id</key><value>gr_pfb_synthesis_filterbank_ccf_0</value></param>
<param><key>numchans</key><value>nchans</value></param>
<param><key>connections</key><value>4</value></param>
<param><key>taps</key><value>taps</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>sig_amp2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_multiply_const_vxx</key>
<param><key>id</key><value>gr_multiply_const_vxx_0_1_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>const</key><value>sig_amp3</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sig_amp0</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sig_amp1</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sig_amp2</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>sig_amp3</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>out_amp</value></param>
<param><key>label</key><value>Output Amplitude</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>1</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>widget</key><value>counter</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_scipy</value></param>
<param><key>import</key><value>import scipy</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>25000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nchans</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>uhd_usrp_sink</key>
<param><key>id</key><value>uhd_usrp_sink_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>quad_rate*nchans</value></param>
<param><key>center_freq0</key><value>uhd.tune_request(freq, -100e3)</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>quad_rate</value></param>
<param><key>value</key><value>samp_rate*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(nchans, quad_rate*nchans, quad_rate/2.0, 10000, 100)</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>quad_rate*nchans</value></param>
</block>
<block>
<key>blks2_dxpsk_mod</key>
<param><key>id</key><value>blks2_dxpsk_mod_0_0</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>gray_code</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>blks2_dxpsk_mod</key>
<param><key>id</key><value>blks2_dxpsk_mod_0_0_0</value></param>
<param><key>type</key><value>d8psk</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>gray_code</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>blks2_dxpsk_mod</key>
<param><key>id</key><value>blks2_dxpsk_mod_0_0_1</value></param>
<param><key>type</key><value>dqpsk</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>excess_bw</key><value>0.35</value></param>
<param><key>gray_code</key><value>True</value></param>
<param><key>verbose</key><value>False</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>sps</value></param>
<param><key>value</key><value>1</value></param>
</block>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>uhd_usrp_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_pfb_synthesis_filterbank_ccf_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0</source_block_id><sink_block_id>blks2_dxpsk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_0</source_block_id><sink_block_id>gr_pfb_synthesis_filterbank_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_dxpsk_mod_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_1</source_block_id><sink_block_id>gr_pfb_synthesis_filterbank_ccf_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0</source_block_id><sink_block_id>blks2_dxpsk_mod_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_dxpsk_mod_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_0</source_block_id><sink_block_id>blks2_dxpsk_mod_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_dxpsk_mod_0_0_0</source_block_id><sink_block_id>gr_multiply_const_vxx_0_1_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_source_x_0_0_1</source_block_id><sink_block_id>blks2_dxpsk_mod_0_0_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_dxpsk_mod_0_0_1</source_block_id><sink_block_id>gr_multiply_const_vxx_0_1_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_1_0</source_block_id><sink_block_id>gr_pfb_synthesis_filterbank_ccf_0</sink_block_id><source_key>0</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>gr_multiply_const_vxx_0_1_1</source_block_id><sink_block_id>gr_pfb_synthesis_filterbank_ccf_0</sink_block_id><source_key>0</source_key><sink_key>3</sink_key></connection>
</flow_graph>
