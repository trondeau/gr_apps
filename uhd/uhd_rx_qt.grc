<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_rx_qt</value></param>
<param><key>title</key><value>Receiver - UHD based with QtGUI</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Gain - WBX</value></param>
<param><key>value</key><value>15</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>31.5</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Freq. - WBX</value></param>
<param><key>value</key><value>440e6</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>stop</key><value>2.2e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>bandwidth</value></param>
<param><key>plotconst</key><value>False</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>ipaddr</value></param>
<param><key>ref_clk</key><value>ext</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>bandwidth</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>label</key><value>Bandwidth</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>W</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ipaddr</value></param>
<param><key>label</key><value>IP Address</value></param>
<param><key>value</key><value>addr=192.168.100.2</value></param>
<param><key>type</key><value>string</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
