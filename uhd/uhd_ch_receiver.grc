<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>uhd_ch_receiver</value></param>
<param><key>title</key><value>Channelizing Receiver</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>description</key><value>Channelizing receiver that shows the wide-band spectrum and divides it into nchan channels. Shows channels 0, 1, and nchans-1.</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>dev_addr</key><value>addr=192.168.10.2</value></param>
<param><key>ref_clk</key><value>ext</value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>freq</value></param>
<param><key>gain0</key><value>gain</value></param>
<param><key>ant0</key><value>TX/RX</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>taps</value></param>
<param><key>value</key><value>firdes.low_pass_2(nchans, samp_rate, chbw/2.0, chbw/10.0, 100)</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_5</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_2</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_3</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Input</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@0</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_4</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0_6</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Channel 0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>chbw</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@1</value></param>
</block>
<block>
<key>blks2_pfb_channelizer_ccf</key>
<param><key>id</key><value>blks2_pfb_channelizer_ccf_0</value></param>
<param><key>nchans</key><value>10</value></param>
<param><key>taps</key><value>taps</value></param>
<param><key>osr</key><value>1.0</value></param>
<param><key>atten</key><value>100</value></param>
</block>
<block>
<key>qtgui_tab_widget</key>
<param><key>id</key><value>qtgui_tab_widget_0</value></param>
<param><key>num_tabs</key><value>4</value></param>
<param><key>label0</key><value>Input</value></param>
<param><key>label1</key><value>Channel 0</value></param>
<param><key>label2</key><value>Channel 1</value></param>
<param><key>label3</key><value>Channel N-1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>WBX - Gain</value></param>
<param><key>value</key><value>25</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>31.5</value></param>
<param><key>step</key><value>0.5</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Freq - WBX</value></param>
<param><key>value</key><value>440e6</value></param>
<param><key>start</key><value>50e6</value></param>
<param><key>stop</key><value>2.2e9</value></param>
<param><key>step</key><value>1e6</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_1_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Channel N-1</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>chbw</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@3</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>Channel 1</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>chbw</value></param>
<param><key>plotconst</key><value>False</value></param>
<param><key>gui_hint</key><value>qtgui_tab_widget_0@2</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nchans</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>nchans*chbw</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>chbw</value></param>
<param><key>value</key><value>250e3</value></param>
</block>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>blks2_pfb_channelizer_ccf_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>gr_null_sink_0_5</sink_block_id><source_key>2</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>gr_null_sink_0_1</sink_block_id><source_key>3</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>gr_null_sink_0_4</sink_block_id><source_key>4</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>gr_null_sink_0_6</sink_block_id><source_key>5</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>gr_null_sink_0_2</sink_block_id><source_key>6</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>gr_null_sink_0_3</sink_block_id><source_key>7</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>gr_null_sink_0_0</sink_block_id><source_key>8</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_sink_x_0_1</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_pfb_channelizer_ccf_0</source_block_id><sink_block_id>qtgui_sink_x_0_1_0</sink_block_id><source_key>9</source_key><sink_key>0</sink_key></connection>
</flow_graph>
