<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ofdm_rx</value></param>
<param><key>title</key><value>OFDM Receiver</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MyDigital</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>fft_len</value></param>
<param><key>label</key><value>FFT Length</value></param>
<param><key>value</key><value>64</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>cp_len</value></param>
<param><key>label</key><value>Lenght of Cyclic Prefix</value></param>
<param><key>value</key><value>16</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>occ_tones</value></param>
<param><key>label</key><value>Number of Occupied Tones</value></param>
<param><key>value</key><value>40</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_time</value></param>
<param><key>label</key><value>timing</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>gr_char_to_float</key>
<param><key>id</key><value>gr_char_to_float_0</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>occ_tones</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_out</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_fft</value></param>
<param><key>label</key><value>fft</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_vector_to_stream</key>
<param><key>id</key><value>gr_vector_to_stream_0_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_items</key><value>fft_len</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_freq</value></param>
<param><key>label</key><value>sync_freq</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>gr_ofdm_frame_acquisition</key>
<param><key>id</key><value>gr_ofdm_frame_acquisition_0</value></param>
<param><key>occ_tones</key><value>occ_tones</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>cp_length</key><value>cp_len</value></param>
<param><key>known_symbol</key><value>known_symbol</value></param>
<param><key>max_fft_shift_len</key><value>2</value></param>
</block>
<block>
<key>blks2_ofdm_sync_pn</key>
<param><key>id</key><value>blks2_ofdm_sync_pn_0</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>cp_length</key><value>cp_len</value></param>
<param><key>logging</key><value>False</value></param>
</block>
<block>
<key>gr_frequency_modulator_fc</key>
<param><key>id</key><value>gr_frequency_modulator_fc_0</value></param>
<param><key>sensitivity</key><value>-2.0/fft_len</value></param>
</block>
<block>
<key>gr_multiply_xx</key>
<param><key>id</key><value>gr_multiply_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_inputs</key><value>2</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_ofdm_sampler</key>
<param><key>id</key><value>gr_ofdm_sampler_0</value></param>
<param><key>fft_length</key><value>fft_len</value></param>
<param><key>symbol_length</key><value>fft_len+cp_len</value></param>
<param><key>timeout</key><value>1000</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>known_symbol</value></param>
<param><key>value</key><value>[-1, 0, -1, 0, 1, 0, -1, 0, -1, 0, 1, 0, 1, 0, -1, 0, -1, 0, -1, 0, 1, 0, -1, 0, 1, 0, 1, 0, -1, 0, -1, 0, -1, 0, -1, 0, -1, 0, 1, 0, -1, 0, 1, 0, -1, 0, -1, 0, -1, 0, 1, 0, 1, 0]</value></param>
</block>
<block>
<key>gr_fft_vxx</key>
<param><key>id</key><value>gr_fft_vxx_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fft_size</key><value>fft_len</value></param>
<param><key>forward</key><value>True</value></param>
<param><key>window</key><value>[]</value></param>
<param><key>shift</key><value>True</value></param>
</block>
<connection><source_block_id>gr_char_to_float_0</source_block_id><sink_block_id>pad_time</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0</source_block_id><sink_block_id>pad_out</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_ofdm_sampler_0</source_block_id><sink_block_id>gr_fft_vxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_ofdm_sampler_0</source_block_id><sink_block_id>gr_ofdm_frame_acquisition_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>gr_vector_to_stream_0_0_0</source_block_id><sink_block_id>pad_fft</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_ofdm_frame_acquisition_0</source_block_id><sink_block_id>gr_char_to_float_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_vxx_0</source_block_id><sink_block_id>gr_ofdm_frame_acquisition_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_ofdm_frame_acquisition_0</source_block_id><sink_block_id>gr_vector_to_stream_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fft_vxx_0</source_block_id><sink_block_id>gr_vector_to_stream_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_ofdm_sync_pn_0</source_block_id><sink_block_id>pad_freq</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>blks2_ofdm_sync_pn_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_multiply_xx_0</source_block_id><sink_block_id>gr_ofdm_sampler_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blks2_ofdm_sync_pn_0</source_block_id><sink_block_id>gr_ofdm_sampler_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>blks2_ofdm_sync_pn_0</source_block_id><sink_block_id>gr_frequency_modulator_fc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_frequency_modulator_fc_0</source_block_id><sink_block_id>gr_multiply_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
</flow_graph>
