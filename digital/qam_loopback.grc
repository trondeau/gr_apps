<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>200000</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>freq</value></param>
<param><key>label</key><value>Frequency Offset</value></param>
<param><key>value</key><value>init_freq</value></param>
<param><key>start</key><value>-0.5</value></param>
<param><key>stop</key><value>0.5</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>noise</value></param>
<param><key>label</key><value>Noise</value></param>
<param><key>value</key><value>init_noise</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>2</value></param>
<param><key>step</key><value>0.01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>init_freq</value></param>
<param><key>label</key><value>Initial frequency offset</value></param>
<param><key>value</key><value>0.02</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>f</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per symbol</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>s</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>init_timing</value></param>
<param><key>label</key><value>Initial timing offset</value></param>
<param><key>value</key><value>1.001</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>t</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>timing</value></param>
<param><key>label</key><value>Timing Offset</value></param>
<param><key>value</key><value>init_timing</value></param>
<param><key>start</key><value>0.99</value></param>
<param><key>stop</key><value>1.01</value></param>
<param><key>step</key><value>0.0001</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<block>
<key>gr_throttle</key>
<param><key>id</key><value>gr_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qam_tx</key>
<param><key>id</key><value>qam_tx_0</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>diff</key><value>True</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>arity</key><value>arity</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>label</key><value>RRC Excess bandwidth</value></param>
<param><key>value</key><value>0.35</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>b</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>plotfreq</key><value>False</value></param>
<param><key>plotwaterfall</key><value>False</value></param>
<param><key>plottime</key><value>False</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
</block>
<block>
<key>qam_rx</key>
<param><key>id</key><value>qam_rx_0</value></param>
<param><key>arity</key><value>arity</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
<param><key>timing_loop_bw</key><value>0.1</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>phase_loop_bw</key><value>2*3.14/100.0</value></param>
<param><key>diff</key><value>True</value></param>
</block>
<block>
<key>gr_null_sink</key>
<param><key>id</key><value>gr_null_sink_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>qtgui_sink_x</key>
<param><key>id</key><value>qtgui_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arity</value></param>
<param><key>label</key><value>Order of modulation</value></param>
<param><key>value</key><value>64</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>short_id</key><value>m</value></param>
</block>
<block>
<key>channel_model</key>
<param><key>id</key><value>channel_model_0</value></param>
<param><key>noise_voltage</key><value>noise</value></param>
<param><key>freq_offset</key><value>freq</value></param>
<param><key>epsilon</key><value>timing</value></param>
<param><key>taps</key><value>1.0</value></param>
<param><key>seed</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>init_noise</value></param>
<param><key>label</key><value>Initial noise valeu</value></param>
<param><key>value</key><value>0.05</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>n</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>qam_loopback</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<connection><source_block_id>gr_throttle_0</source_block_id><sink_block_id>channel_model_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_model_0</source_block_id><sink_block_id>qtgui_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qam_tx_0</source_block_id><sink_block_id>gr_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>channel_model_0</source_block_id><sink_block_id>qam_rx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qam_rx_0</source_block_id><sink_block_id>qtgui_sink_x_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>qam_rx_0</source_block_id><sink_block_id>gr_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
