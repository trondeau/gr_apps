<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>psk_rx</value></param>
<param><key>title</key><value>M-PSK - Receiver</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>description</key><value>Receive M-PSK signals to samples</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MyDigital</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arity</value></param>
<param><key>label</key><value>Order of the constellation</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>label</key><value>Excess Bandwidth</value></param>
<param><key>value</key><value>0.35</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>11*nfilts*sps</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>pfb_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, ntaps)</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>timing_loop_bw</value></param>
<param><key>label</key><value>Timing Loop's BW</value></param>
<param><key>value</key><value>0.1</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>digital_costas_loop_cc</key>
<param><key>id</key><value>digital_costas_loop_cc_0</value></param>
<param><key>w</key><value>phase_loop_bw</value></param>
<param><key>order</key><value>arity</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_pfb_clock_sync_xxx</key>
<param><key>id</key><value>gr_pfb_clock_sync_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>alpha</key><value>timing_loop_bw</value></param>
<param><key>beta</key><value>0.25*timing_loop_bw*timing_loop_bw</value></param>
<param><key>taps</key><value>pfb_taps</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>max_dev</key><value>1</value></param>
<param><key>osps</key><value>1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>phase_loop_bw</value></param>
<param><key>label</key><value>Phase Loop's BW</value></param>
<param><key>value</key><value>2*3.14/100.0</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<connection><source_block_id>gr_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>digital_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_costas_loop_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gr_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
