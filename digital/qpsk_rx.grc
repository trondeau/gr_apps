<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>variable</key>
<param><key>id</key><value>pfb_taps</value></param>
<param><key>value</key><value>firdes.root_raised_cosine(nfilts, nfilts, 1.0/float(sps), excess_bw, ntaps)</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_pfb_clock_sync_xxx</key>
<param><key>id</key><value>gr_pfb_clock_sync_xxx_0</value></param>
<param><key>type</key><value>ccf</value></param>
<param><key>sps</key><value>sps</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>beta</key><value>0.01</value></param>
<param><key>taps</key><value>pfb_taps</value></param>
<param><key>filter_size</key><value>nfilts</value></param>
<param><key>init_phase</key><value>nfilts/2</value></param>
<param><key>max_dev</key><value>1</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>gr_fll_band_edge_cc</key>
<param><key>id</key><value>gr_fll_band_edge_cc_0</value></param>
<param><key>type</key><value>cc</value></param>
<param><key>samps_per_sym</key><value>sps</value></param>
<param><key>rolloff</key><value>excess_bw</value></param>
<param><key>filter_size</key><value>11*sps</value></param>
<param><key>alpha</key><value>0.010</value></param>
<param><key>beta</key><value>0.001</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>value</key><value>2</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>label</key><value>Excess Bandwidth</value></param>
<param><key>value</key><value>0.35</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>nfilts</value></param>
<param><key>value</key><value>32</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>ntaps</value></param>
<param><key>value</key><value>11*nfilts*sps</value></param>
</block>
<block>
<key>gr_costas_loop_cc</key>
<param><key>id</key><value>gr_costas_loop_cc_0</value></param>
<param><key>alpha</key><value>0.1</value></param>
<param><key>beta</key><value>0.01</value></param>
<param><key>max_freq</key><value>0.5</value></param>
<param><key>min_freq</key><value>-0.5</value></param>
<param><key>order</key><value>4</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>qpsk_rx</value></param>
<param><key>title</key><value>QPSK - Receiver</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>description</key><value>Receive QPSK signals to samples</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MyDigital</value></param>
</block>
<connection><source_block_id>gr_pfb_clock_sync_xxx_0</source_block_id><sink_block_id>gr_costas_loop_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_costas_loop_cc_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>gr_fll_band_edge_cc_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>gr_fll_band_edge_cc_0</source_block_id><sink_block_id>gr_pfb_clock_sync_xxx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
