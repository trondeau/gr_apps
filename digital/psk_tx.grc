<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>import</key>
<param><key>id</key><value>import_scipy</value></param>
<param><key>import</key><value>import scipy</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>excess_bw</value></param>
<param><key>label</key><value>Excess Bandwidth</value></param>
<param><key>value</key><value>0.35</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>arity</value></param>
<param><key>label</key><value>Order of the constellation</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>diff</value></param>
<param><key>label</key><value>Use differential encoding</value></param>
<param><key>value</key><value>True</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>gr_vector_source_x</key>
<param><key>id</key><value>gr_vector_source_x_0</value></param>
<param><key>type</key><value>byte</value></param>
<param><key>vector</key><value>scipy.array(scipy.random.randint(0,256,10000), dtype=scipy.uint8).tolist()</value></param>
<param><key>repeat</key><value>True</value></param>
<param><key>vlen</key><value>1</value></param>
</block>
<block>
<key>digital_psk_mod</key>
<param><key>id</key><value>digital_psk_mod_0</value></param>
<param><key>constellation_points</key><value>arity</value></param>
<param><key>mod_code</key><value>"gray"</value></param>
<param><key>differential</key><value>diff</value></param>
<param><key>samples_per_symbol</key><value>sps</value></param>
<param><key>excess_bw</key><value>excess_bw</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>label</key><value>out</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>sps</value></param>
<param><key>label</key><value>Samples per Symbol</value></param>
<param><key>value</key><value>4</value></param>
<param><key>type</key><value>intx</value></param>
</block>
<block>
<key>options</key>
<param><key>id</key><value>psk_tx</value></param>
<param><key>title</key><value>M-PSK - Transmitter</value></param>
<param><key>author</key><value>Tom Rondeau</value></param>
<param><key>description</key><value>Transmit M-PSK signals to samples</value></param>
<param><key>generate_options</key><value>hb</value></param>
<param><key>category</key><value>MyDigital</value></param>
</block>
<connection><source_block_id>gr_vector_source_x_0</source_block_id><sink_block_id>digital_psk_mod_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>digital_psk_mod_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
